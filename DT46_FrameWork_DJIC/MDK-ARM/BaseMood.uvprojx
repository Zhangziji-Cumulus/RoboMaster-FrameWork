# Keil uVision project BaseMood.uvprojx, settings and files
target BaseMood (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: BaseMood +hex
  c flags: OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=1
  c define: USE_HAL_DRIVER,STM32F407xx,USE_HAL_DRIVER,STM32F407xx,ARM_MATH_CM4,__FPU_USED=1U,__FPU_PRESENT=1U,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;./UserAppliction;./UserDrive;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;./AAA;./AADrivers;./AADrivers/IMU;./AADrivers/IMU/BMI088;./ABModule;./ABModule/Buzzer;./ACApplication;./ACApplication/Auto;./ACApplication/Chassis;./ACApplication/Gimbal;./ACApplication/RobotConfig;./ACApplication/Shooting;./ACApplication/MotorAPP;./ABModule/ZDT;./ABModule/Referee;./ABModule/VT;./ABModule/PlayerUI;./ABModule/CRC;./ABModule/RefereeTx;./ABModule/Printf;.\ABModule\DM;.\ABModule\SuperPower
  asm include: ../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c can.c dma.c i2c.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group AAA
    ./AAA/: A_MCommon.h A_CommonDrivers.h A_CommonModules.h A_CommonSystem.h
  group AADrivers
    ./AADrivers/: bsp_CAN.c bsp_CAN.h bsp_Init.c bsp_Init.h bsp_SBUS.c bsp_SBUS.h Dual_board_Transmit.c Dual_board_Transmit.h Dual_Board_Transmit_Task.c Dual_Board_Transmit_Task.h bsp_usart.c bsp_usart.h
  group AADrivers/IMU/BMI088
    ./AADrivers/IMU/BMI088/: AHRS.h AHRS.lib AHRS_middleware.c AHRS_middleware.h arm_math.h BMI088driver.c BMI088driver.h BMI088Middleware.c BMI088Middleware.h BMI088reg.h bsp_delay.c bsp_delay.h bsp_imu_pwm.c bsp_imu_pwm.h bsp_rc.c bsp_rc.h bsp_spi.c bsp_spi.h IMU_PID.c IMU_PID.h INS_task.c INS_task.h ist8310driver.c ist8310driver.h ist8310driver_middleware.c ist8310driver_middleware.h struct_typedef.h user_lib.c user_lib.h
  group ABModule
    ./ABModule/: PID_Lib.c PID_Lib.h CMDCenter.c CMDCenter.h Math_Lib.c Math_Lib.h MotorCtrl_DJI.c MotorCtrl_DJI.h MotorCtrl_ZDT.c MotorCtrl_ZDT.h Remote_Ctrl.c Remote_Ctrl.h User_CallBack.c User_CallBack.h MotorCtrl_DJI_STOP.c MotorCtrl_DJI_STOP.h MotorCtrl_DJI_Check_Task.c MotorCtrl_DJI_Check_Task.h
  group ABModule/Buzzer
    ./ABModule/Buzzer/: bsp_buzzer_driver.c bsp_buzzer_driver.h buzzer_TIM_init.c buzzer_TIM_init.h sound_effects_task.c sound_effects_task.h
  group ABModule/ZDT
    ./ABModule/ZDT/: ZDT_Emm_V5.c ZDT_Emm_V5.h ZDT_X_V2.c ZDT_X_V2.h ZDT_CAN_Bsp.c ZDT_CAN_Bsp.h ZDT_Firmware.h
  group ABModule/Referee
    ./ABModule/Referee/: RefereeProtocol.c RefereeProtocol.h RefereeCenter.c RefereeCenter.h
  group ABModule/VT
    ./ABModule/VT/: VTCenter.c VTCenter.h VT03Protocol.c VT03Protocol.h VTCenter_Instance.c VTCenter_Instance.h AdvancedKeyOperation.c AdvancedKeyOperation.h
  group ABModule/PlayerUI
    ./ABModule/PlayerUI/: PlayerUI_Task.c PlayerUI_Task.h ui.h ui_interface.c ui_interface.h ui_types.h DrawUI.c DrawUI.h DrawUI_Extend.c DrawUI_Extend.h ui_Dynamic.c ui_Dynamic.h ui_Static.c ui_Static.h ui_Dynamic2.c ui_Dynamic2.h
  group ABModule/CRC
    ./ABModule/CRC/: CRC.c CRC.h
  group ABModule/Printf
    ./ABModule/Printf/: Printf.c Printf.h Printf_Task.c Printf_Task.h
  group ABModule/DM
    ./ABModule/DM/: dm_motor_ctrl.c dm_motor_ctrl.h dm_motor_drv.c dm_motor_drv.h dm_bsp_can.c dm_bsp_can.h
  group ACApplication/Auto
    ./ACApplication/Auto/: Auto_Config.h AutoAim.c AutoAim.h AutoNavigation.c AutoNavigation.h AutoShooting.c AutoShooting.h AutoAim_Task.c AutoAim_Task.h
  group ACApplication/Chassis
    ./ACApplication/Chassis/: Chassis_Config.h Chassis_leg.c Chassis_leg.h Chassis_Mecanu.c Chassis_Mecanu.h Chassis_Omni.c Chassis_Omni.h Chassis_Steering.c Chassis_Steering.h Chassis_Task.c Chassis_Task.h Chassis_Advanced.c Chassis_Advanced.h
  group ACApplication/Gimbal
    ./ACApplication/Gimbal/: Gimbal_Config.h Gimbal_Task.c Gimbal_Task.h Gimbal_Hero.c Gimbal_Hero.h
  group ACApplication/RobotConfig
    ./ACApplication/RobotConfig/: Robot_Hero_Config.h
  group ACApplication/Shooting
    ./ACApplication/Shooting/: Shooting_Config.h Shooting_Task.c Shooting_Task.h Shooting_Hero.c Shooting_Hero.h Load_Task.c Load_Task.h
  group ACApplication
    ./ACApplication/: APP_Config.h Application_Logic_Core.h
  group ABModule/SuperPower
    ./ABModule/SuperPower/: SuperPower.c SuperPower.h
software components: CMSIS:CORE 4.3.0
